# Repository noahmulkis/CyberDock

File README.md:

<h1 align="center">CyberDock</h1>

<p align="center">
  Welcome to CyberDock, my custom 3D printed Macropad that runs KMK firmware.
</p>

<hr>

<h2>PCB and Schematic</h2>

<p align="center">
  
" />
</p>

<hr>

<h2>Bill of Materials:</h2>

<ul>
  <li>1x CyberDock PCB</li>
  <li>1x XIAO-PR2040-DIP</li>
  <li>1x EC11 rotary encoder</li>
  <li>11x Cherry MX (or equivalent) keyswitches</li>
  <li>11x Keycaps</li>
  <li>12x 1N4148 Throughhole diodes</li>
  <li>1x 0.91 inch OLED display (SSD1306 I2C 0.91 128x32)</li>
  <li>4x Cap head M3x16 machine screws</li>
  <li>1x 3D printed shell top half</li>
  <li>1x 3D printed shell bottom half</li>
</ul>

<p>
  small amount of spare wire apprx. 50mm worth.
</p>

<hr>

<h2>Instructions for Assembly:</h2>

<ol>
  <li>Solder RP2040 directly onto the pcb without a header.</li>
  <li>Solder on Diodes aligning with the slikscreen.</li>
  <li>Solder CherryMX switches to board.</li>
  <li>
    Solder breakout cables to the spare 4 pins near the RP2040, these will be used to wire to the OLED display.
    Make these breakout cables ~2" to allow for easier soledering.
  </li>
  <li>
    Clamshell the base around the PCB, passing the breakout cables through the small hole in the gap for the display
    in the top half of the case, then use the M3x16 machine screws to clamp the assembly together.
  </li>

  <li>Solder display to the breakout cables</li>
  <li>Use double-sided tape or a light adhesive to hold the OLED into its holder,.</li>

</ol>

## KiCad design PCB/CyberDock.kicad_pcb

Parts:
D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
O1: FanPinHeader_1x04_P2.54mm_Vertical
RE1: RotaryEncoder_Alps_EC11E-Switch_Vertical_H20mm
SW1, SW2, SW3, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12: SW_Push_45deg; SW_Cherry_MX_1.00u_PCB
U1: XIAO-RP2040-DIP

Connections:
+5V: O1.2 (VCC), U1.14 (VBUS)
Column 0: SW1.1, SW5.1, SW9.1, U1.11 (GPIO3/MOSI)
Column 1: SW2.1, SW6.1, SW10.1, U1.10 (GPIO4/MISO)
Column 2: SW3.1, SW7.1, SW11.1, U1.9 (GPIO2/SCK)
Column 3: RE1.S2 (SW), SW8.1, SW12.1, U1.8 (GPIO1/RX)
GND: O1.1 (GND), RE1.C, U1.13 (GND)
unnamed: D2.2 (A), SW1.2
unnamed: D3.2 (A), SW2.2
unnamed: D4.2 (A), SW3.2
unnamed: D5.2 (A), RE1.S1 (SW)
unnamed: D6.2 (A), SW5.2
unnamed: D7.2 (A), SW6.2
unnamed: D8.2 (A), SW7.2
unnamed: D9.2 (A), SW8.2
unnamed: D10.2 (A), SW9.2
unnamed: D11.2 (A), SW10.2
unnamed: D12.2 (A), SW11.2
unnamed: D13.2 (A), SW12.2
unnamed: O1.3 (SCL), U1.6 (GPIO7/SCL)
unnamed: O1.4 (SDA), U1.5 (GPIO6/SDA)
unnamed: RE1.B, U1.7 (GPIO0/TX)
unnamed: RE1.A, U1.4 (GPIO29/ADC3/A3)
Row 0: D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), U1.3 (GPIO28/ADC2/A2)
Row 1: D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), U1.2 (GPIO27/ADC1/A1)
Row 2: D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), U1.1 (GPIO26/ADC0/A0)

Board: 2 copper layers, 82.0 x 79.6 mm, 26 parts (0 on the bottom side), 25 nets.

## Commit log

2026-02-26 Update assembly instructions in README
